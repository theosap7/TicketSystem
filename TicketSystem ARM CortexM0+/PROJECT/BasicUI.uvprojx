# Keil uVision project BasicUI.uvprojx, settings and files
target KL25Z Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BasicUI
  c flags: Optim=4
  c include: include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  link misc: --libpath C:\Keil_v5\ARM\ARMCC\lib
  group Startup
    ./: startup_MKL25Z4.s
    ./src/: system_MKL25Z4.c
  group source
    ./src/: main.c
  group include
    ./include/: gpio_defs.h lcd_4bit.h switches.h
software components: CMSIS:CORE 4.3.0
